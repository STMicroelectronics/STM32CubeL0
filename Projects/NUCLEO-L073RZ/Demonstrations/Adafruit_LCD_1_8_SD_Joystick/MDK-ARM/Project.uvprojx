# Keil uVision project Project.uvprojx, settings and files
target STM32L073RZ_NUCLEO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.2
  cpu: IROM(0x08000000-0x802FFFF) IRAM(0x20000000-0x20004FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L073xx,USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32L0xx_Nucleo;../../../../../Drivers/BSP/Adafruit_Shield;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Drivers/BSP/Components;../../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Demo/MDK-ARM
    ./: startup_stm32l073xx.s
  group Demo/User
    ../Src/: fatfs_storage.c main.c stm32l0xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Adafruit_Shield
    ../../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_lcd.c stm32_adafruit_sd.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/st7735/: st7735.c
  group Drivers/BSP/STM32L0xx_Nucleo
    ../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../Src/: sd_diskio.c
software components: CMSIS:CORE 4.3.0
