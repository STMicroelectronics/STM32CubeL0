# Keil uVision project Project.uvprojx, settings and files
target STM32L073RZ_NUCLEO (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x00030000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: STM32L073RZ_NUCLEO
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L073xx,USE_STM32L0XX_NUCLEO,VECT_TAB_SRAM
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x3000
  memory RVCT9: RAM 0x20003000 size 0x2000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: stm32l0xx_it.c main.c
  group Example/MDK-ARM
    ./: startup_stm32l073xx.s
  group Drivers/STM32L0xx_LL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_utils.c
software components: CMSIS:CORE 4.3.0
