# Keil uVision project Project.uvprojx, settings and files
target STM32L073RZ_NUCLEO (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L073RZ_NUCLEO
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L073xx,USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L0xx_Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Doc
    ../: readme.txt
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_dac.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr_ex.c stm32l0xx_ll_utils.c stm32l0xx_hal.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_tim.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_cortex.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_gpio.c
  group Example/User
    ../Src/: stm32l0xx_it.c stm32l0xx_hal_msp.c main.c
  group Example/MDK-ARM
    ./: startup_stm32l073xx.s
  group Drivers/BSP/STM32L0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
software components: CMSIS:CORE 4.3.0
