# Keil uVision project USBD_DFU.uvprojx, settings and files
target STM32L073Z_EVAL (ARM-ADS)
  device: STM32L073VZTx STMicroelectronics
  cpu: IROM(0x08000000-0x802FFFF) IRAM(0x20000000-0x20004FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L073Z-EVAL_USBD-FS
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L073xx,USE_STM32L073Z_EVAL,USE_HAL_DRIVER
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Inc;../../../../../../Drivers/BSP/STM32L073Z_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/mfxstm32l152
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32l073xx.s
  group Application/User
    ../Src/: main.c stm32l0xx_it.c usbd_conf.c usbd_desc.c usbd_dfu_flash.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L073Z_EVAL
    ../../../../../../Drivers/BSP/STM32L073Z_EVAL/: stm32l073z_eval.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_ll_usb.c
  group Middlewares/STM32_USBD_Library/Class/DFU
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
software components: CMSIS:CORE 4.3.0
