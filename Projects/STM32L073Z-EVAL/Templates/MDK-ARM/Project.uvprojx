# Keil uVision project Project.uvprojx, settings and files
target STM32L073Z_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L073VZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.2
  cpu: IROM(0x08000000-0x802FFFF) IRAM(0x20000000-0x20004FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: stm32l073z_eval
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L073xx,USE_STM32L073Z_EVAL,USE_HAL_DRIVER
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32L073Z_EVAL;../../../../Drivers/BSP/Components/Common;../../../../Drivers/BSP/Components/mfxstm32l152
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Drivers/BSP/STM32L073Z_EVAL
    ../../../../Drivers/BSP/STM32L073Z_EVAL/: stm32l073z_eval.c stm32l073z_eval_io.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c stm32l0xx_ll_usb.c
  group Example/MDK-ARM
    ./: startup_stm32l073xx.s
  group Example/User
    ../Src/: main.c stm32l0xx_it.c
software components: CMSIS:CORE 4.3.0
