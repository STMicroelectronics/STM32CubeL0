# Keil uVision project Project.uvprojx, settings and files
target FLASH_DualBoot_Bank1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L073VZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: FLASH_DualBoot_Bank1
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L073xx,USE_HAL_DRIVER,USE_STM32L073Z_EVAL,FLASH_BANK1
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L073Z_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32l073xx.s
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/BSP/STM32L073Z_EVAL
    ../../../../../../Drivers/BSP/STM32L073Z_EVAL/: stm32l073z_eval_io.c stm32l073z_eval.c stm32l073z_eval_lcd.c
  group Example/User
    ../Src/: main.c stm32l0xx_it.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_gpio.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_i2c.c stm32l0xx_hal_usart.c stm32l0xx_hal.c
target FLASH_DualBoot_Bank2 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L073VZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: as above
  output: FLASH_DualBoot_Bank2
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L073xx,USE_HAL_DRIVER,USE_STM32L073Z_EVAL,FLASH_BANK2
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 4.3.0
