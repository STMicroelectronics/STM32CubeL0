# Keil uVision project Project.uvprojx, settings and files
target STM32L073Z_EVAL (ARM-ADS)
  device: STM32L073VZTx STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L073Z_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L073xx,USE_STM32L073Z_EVAL,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L073Z_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/mfxstm32l152
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32l073xx.s
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_smbus.c stm32l0xx_hal_rcc.c stm32l0xx_hal_dma.c stm32l0xx_hal.c stm32l0xx_hal_gpio.c stm32l0xx_hal_spi.c stm32l0xx_hal_cortex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Example/User
    ../Src/: stm32l0xx_hal_msp.c stm32l0xx_tsensor.c main.c stm32l0xx_it.c
  group Drivers/BSP/STM32L073Z_EVAL
    ../../../../../../Drivers/BSP/STM32L073Z_EVAL/: stm32l073z_eval.c stm32l073z_eval_lcd.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
software components: CMSIS:CORE 4.3.0
