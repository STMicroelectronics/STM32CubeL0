# Keil uVision project Project.uvprojx, settings and files
target STM32L073Z_EVAL (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L073VZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L073Z_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L073xx,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../Drivers/STM32L0xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32l073xx.s
  group Example/User
    ../Src/: main.c stm32l0xx_it.c
  group Drivers/STM32L0xx_LL_Driver
    ../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_adc.c stm32l0xx_ll_lptim.c stm32l0xx_ll_rtc.c stm32l0xx_ll_comp.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_dac.c stm32l0xx_ll_utils.c stm32l0xx_ll_rng.c stm32l0xx_ll_crs.c stm32l0xx_ll_exti.c stm32l0xx_ll_i2c.c stm32l0xx_ll_dma.c stm32l0xx_ll_rcc.c stm32l0xx_ll_pwr.c stm32l0xx_ll_spi.c stm32l0xx_ll_crc.c stm32l0xx_ll_gpio.c stm32l0xx_ll_usart.c stm32l0xx_ll_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
software components: CMSIS:CORE 4.3.0
