# Keil uVision project Project.uvprojx, settings and files
target STM32L0xx_Discovery (ARM-ADS)
  device: STM32L053C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L0xx_Discovery
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L053xx
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_TouchSensing_Library/inc
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32l053xx.s
  group Middlewares/STM32_TouchSensing_Library
    ../../../../../../Middlewares/ST/STM32_TouchSensing_Library/src/: tsl_acq.c tsl_time.c tsl_dxs.c tsl_linrot.c tsl_filter.c tsl_touchkey.c tsl_object.c tsl.c tsl_acq_tsc.c tsl_globals.c tsl_ecs.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_cortex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal.c stm32l0xx_hal_gpio.c stm32l0xx_hal_tsc.c
  group Example/User
    ../Src/: tsl_user.c main.c stm32l0xx_hal_msp.c stmCriticalSection.c stm32l0xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
software components: CMSIS:CORE 4.3.0
