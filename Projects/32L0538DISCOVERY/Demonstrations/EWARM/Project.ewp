# IAR project Project.ewp, settings and files
configuration STM32L0538-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053C8 ST STM32L053C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L053xx; USE_STM32L0538_DISCO
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\Config; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\Drivers\BSP\STM32L0538-Discovery; ..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ..\..\..\..\Middlewares\ST\STM32_TouchSensing_Library\inc; ..\..\..\..\Drivers\BSP\Components; ..\..\..\..\Drivers\BSP\Components\Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: STM32L053C8-Discovery_Demo.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l053xx.s
  group Application/User/Core
    ../Core/Src/: bsp.c main.c menu.c stm32l0xx_hal_msp.c stm32l0xx_it.c tsl_user.c
  group Application/User/Modules/IddMeasurement
    ../Modules/iddmeasurement/: power.c
  group Application/User/Modules/USB HID
    ../Modules/usbHID/: usbd_conf.c usbd_desc.c usbdapp.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Compnents
    ../../../../Drivers/BSP/Components/gde021a1/: gde021a1.c
    ../../../../Drivers/BSP/Components/gdem0213b74/: gdem0213b74.c
  group Drivers/BSP/STM32L0538-Discovery
    ../../../../Drivers/BSP/STM32L0538-Discovery/: stm32l0538_discovery.c stm32l0538_discovery_epd.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tsc.c stm32l0xx_ll_usb.c
  group Middlewares/TouchSensing_Library
    ../../../../Middlewares/ST/STM32_TouchSensing_Library/src/: tsl.c tsl_acq.c tsl_acq_tsc.c tsl_dxs.c tsl_ecs.c tsl_filter.c tsl_globals.c tsl_linrot.c tsl_object.c tsl_time.c tsl_touchkey.c
  group Middlewares/USBD_Library/Class/HID
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Middlewares/USBD_Library/Core
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
