# IAR project Project.ewp, settings and files
configuration STM32L0538-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053C8 ST STM32L053C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L053xx; USE_STM32L0538_DISCO
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32L0538-Discovery; ..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\Drivers\BSP\Components\Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: STM32L053C8-Discovery_Demo.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32L0538-Discovery-RevB03 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L053xx; USE_STM32L0538_DISCO_REV_B03
  group Application/EWARM
    ./: startup_stm32l053xx.s
  group Application/User
    ../Src/: bsp.c main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Compnents
    ../../../../../Drivers/BSP/Components/gde021a1/: gde021a1.c
    ../../../../../Drivers/BSP/Components/gdem0213b74/: gdem0213b74.c
  group Drivers/BSP/STM32L0538-Discovery
    ../../../../../Drivers/BSP/STM32L0538-Discovery/: stm32l0538_discovery.c stm32l0538_discovery_epd.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c
