# Keil uVision project Project.uvprojx, settings and files
target STM32L053C8_Discovery (ARM-ADS)
  device: STM32L053C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L053C8_Discovery
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L053xx,USE_STM32L0538_DISCO,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L0538-Discovery
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32L053C8_Discovery
    ../../../../../../Drivers/BSP/STM32L0538-Discovery/: stm32l0538_discovery.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_dac_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_adc.c stm32l0xx_hal_dac.c stm32l0xx_hal_dma.c stm32l0xx_hal_i2c.c stm32l0xx_hal_spi.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal.c stm32l0xx_hal_rcc.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_lptim.c stm32l0xx_hal_comp.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc_ex.c
  group Example/User
    ../Src/: stm32l0xx_hal_msp.c main.c stm32l0xx_it.c
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32l053xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
software components: CMSIS:CORE 4.3.0
