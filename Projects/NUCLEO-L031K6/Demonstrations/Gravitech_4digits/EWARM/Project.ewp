# IAR project Project.ewp, settings and files
configuration STM32L031K6_NUCLEO (ARM, debug)
  General.OGChipSelectEditMenu: STM32L031K6 ST STM32L031K6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32L031xx; USE_STM32L0XX_NUCLEO_32; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo_32; ..\..\..\..\..\Drivers\BSP\Gravitech_4DigitsDisplay_NanoShield; ../../../../../Drivers/BSP/Gravitech_4DigitsDisplay_NanoShield
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32CubeL0_Demo_Nucleo32.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l031xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Demo/User
    ../Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Gravitech_Shield
    ../../../../../Drivers/BSP/Gravitech_4DigitsDisplay_NanoShield/: stm32_gravitech_4digits.c
  group Drivers/BSP/STM32L0xx_Nucleo_32
    ../../../../../Drivers/BSP/STM32L0xx_Nucleo_32/: stm32l0xx_nucleo_32.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c
  group Example/EWARM
    ./: startup_stm32l031xx.s
