# Keil uVision project Project.uvprojx, settings and files
target STM32L031K6_NUCLEO (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L031K6 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L031K6_NUCLEO
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L031xx,USE_STM32L0XX_NUCLEO_32,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32L0xx_Nucleo_32;../../../../../Drivers/BSP/Gravitech_4DigitsDisplay_NanoShield;../../../../../Drivers/BSP/Gravitech_4DigitsDisplay_NanoShield
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32l031xx.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/Gravitech_Shield
    ../../../../../Drivers/BSP/Gravitech_4DigitsDisplay_NanoShield/: stm32_gravitech_4digits.c
  group Drivers/BSP/STM32L0xx_Nucleo_32
    ../../../../../Drivers/BSP/STM32L0xx_Nucleo_32/: stm32l0xx_nucleo_32.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Demo/User
    ../Src/: stm32l0xx_hal_msp.c main.c stm32l0xx_it.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_dma.c stm32l0xx_hal.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_i2c.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_pwr.c
software components: CMSIS:CORE 4.3.0
