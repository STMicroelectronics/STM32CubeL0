# Keil uVision project Project.uvprojx, settings and files
target STM32L010RB_NUCLEO (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L010RBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.2
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20004FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L010xB,USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32L0xx_Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l010xb.s
  group Drivers/BSP/STM32L0xx_Nucleo
    ../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Example/User
    ../Src/: stm32l0xx_hal_msp.c main.c stm32l0xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Doc
    ../: readme.txt
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_tim.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_adc.c stm32l0xx_hal_dma.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_lptim.c stm32l0xx_hal_irda.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal.c stm32l0xx_hal_usart.c stm32l0xx_hal_spi.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_pwr.c stm32l0xx_hal_gpio.c stm32l0xx_hal_wwdg.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_crc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_tim_ex.c
software components: CMSIS:CORE 4.3.0
