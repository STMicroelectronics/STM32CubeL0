# Keil uVision project Project.uvprojx, settings and files
target STM32L011K4_NUCLEO (ARM-ADS)
  device: STM32L021K4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L011K4_NUCLEO
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L021xx,USE_STM32L0XX_NUCLEO_32,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L0xx_Nucleo_32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Example/User
    ../Src/: stm32l0xx_hal_msp.c stm32l0xx_it.c main.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_cortex.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_uart.c stm32l0xx_hal_dma.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_rcc.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_gpio.c
  group Example/MDK-ARM
    ./: startup_stm32l021xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Doc
    ../: Expected_Results.txt readme.txt
  group Drivers/BSP/STM32L0xx_Nucleo_32
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo_32/: stm32l0xx_nucleo_32.c
software components: CMSIS:CORE 4.1.0
