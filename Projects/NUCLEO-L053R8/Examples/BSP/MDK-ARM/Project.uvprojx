# Keil uVision project Project.uvprojx, settings and files
target STM32L053R8_NUCLEO (ARM-ADS)
  device: STM32L053R8Tx STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L053R8_NUCLEO
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L053xx,USE_STM32L0XX_NUCLEO
  c misc: --C99
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32L0xx_Nucleo;../../../../../Drivers/BSP/Adafruit_Shield
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L053R8_NUCLEO
    ../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_cortex.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal.c stm32l0xx_hal_flash.c stm32l0xx_hal_dma.c stm32l0xx_hal_rcc.c stm32l0xx_hal_adc.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_spi.c stm32l0xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Example/User
    ../Src/: stm32l0xx_it.c lcd.c joystick.c main.c sd.c
  group Drivers/BSP/Adafruit_Shield
    ../../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_sd.c stm32_adafruit_lcd.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/st7735/: st7735.c
  group Example/MDK-ARM
    ./: startup_stm32l053xx.s
software components: CMSIS:CORE 4.3.0
