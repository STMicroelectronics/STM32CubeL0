# Keil uVision project Project.uvprojx, settings and files
target STM32L053R8_NUCLEO (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: STM32L053R8_NUCLEO
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L053xx,USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L0xx_Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Doc
    ../: readme.txt
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_cortex.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dma.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal.c stm32l0xx_hal_rcc.c stm32l0xx_hal_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Example/User
    ../Src/: stm32l0xx_it.c stm32l0xx_hal_msp.c main.c
  group Example/MDK-ARM
    ./: startup_stm32l053xx.s
  group Drivers/BSP/STM32L0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
software components: CMSIS:CORE 4.3.0
